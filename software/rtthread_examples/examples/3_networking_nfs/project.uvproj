# Keil uVision project project.uvproj, settings and files
target rt-thread_lpc40xx (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-lpc40xx +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\..\libraries\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\libraries\CMSIS\Include;..\..\libraries\Drivers\include;..\..\drivers;applications;.;..\..\..\..\..\Mygithub\include;..\..\..\..\..\Mygithub\libcpu\arm\cortex-m4;..\..\..\..\..\Mygithub\libcpu\arm\common;..\..\..\..\..\Mygithub\components\dfs\include;..\..\..\..\..\Mygithub\components\dfs\filesystems\devfs;..\..\..\..\..\Mygithub\components\dfs\filesystems\elmfat;..\..\..\..\..\Mygithub\components\dfs\filesystems\nfs;..\..\..\..\..\Mygithub\components\drivers\include;..\..\..\..\..\Mygithub\components\drivers\include;..\..\..\..\..\Mygithub\components\finsh;..\..\..\..\..\Mygithub\components\net\lwip-1.4.1\src;..\..\..\..\..\Mygithub\components\net\lwip-1.4.1\src\include;..\..\..\..\..\Mygithub\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\..\Mygithub\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\..\Mygithub\components\net\lwip-1.4.1\src\include\netif;..\..\..\..\..\Mygithub\components\pthreads;..\..\..\..\..\Mygithub\components\libc\armlibc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\rtthread-lpc408x.sct
  link misc: --keep *.o(RTMSymTab)  --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Libraries
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
    ../../libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_sram.c drv_sdram.c drv_led.c drv_mpu.c drv_sd.c drv_emac.c
  group Applications
    applications/: application.c startup.c
  group Kernel
    ../../../../../Mygithub/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../../../Mygithub/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../../Mygithub/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../../Mygithub/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../../Mygithub/components/dfs/filesystems/devfs/: console.c devfs.c
    ../../../../../Mygithub/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../../Mygithub/components/dfs/filesystems/elmfat/option/: ccfile.c
    ../../../../../Mygithub/components/dfs/filesystems/nfs/: dfs_nfs.c mount_clnt.c mount_xdr.c nfs_clnt.c nfs_xdr.c
    ../../../../../Mygithub/components/dfs/filesystems/nfs/rpc/: auth_none.c clnt_generic.c clnt_udp.c pmap.c rpc_prot.c xdr.c xdr_mem.c
  group DeviceDrivers
    ../../../../../Mygithub/components/drivers/serial/: serial.c
    ../../../../../Mygithub/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../../../Mygithub/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group LwIP
    ../../../../../Mygithub/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../Mygithub/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../../../Mygithub/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../Mygithub/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../Mygithub/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
