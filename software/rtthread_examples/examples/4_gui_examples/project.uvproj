# Keil uVision project project.uvproj, settings and files
target rt-thread_lpc40xx (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-lpc40xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: CORE_M4
  c include: ..\..\libraries\Device\NXP\LPC407x_8x_177x_8x\Include;..\..\libraries\CMSIS\Include;..\..\libraries\Drivers\include;..\..\drivers;applications;.;..\..\..\..\..\Mygithub\include;..\..\..\..\..\Mygithub\libcpu\arm\cortex-m4;..\..\..\..\..\Mygithub\libcpu\arm\common;..\..\..\..\..\Mygithub\components\dfs\include;..\..\..\..\..\Mygithub\components\dfs\filesystems\elmfat;..\..\..\..\..\Mygithub\components\drivers\include;..\..\..\..\..\Mygithub\components\drivers\spi;..\..\..\..\..\Mygithub\components\drivers\include;..\..\..\..\..\Mygithub\components\drivers\include;..\..\..\..\..\Mygithub\components\finsh;..\..\..\..\..\Mygithub\components\rtgui\include;..\..\..\..\..\Mygithub\components\rtgui\include;..\..\..\..\..\Mygithub\components\rtgui\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Libraries
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    ../../libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
    ../../libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
  group Drivers
    ../../drivers/: board.c drv_uart.c drv_sram.c drv_sdram.c drv_led.c drv_mpu.c drv_sd.c drv_spi.c drv_lcd.c drv_key.c drv_touch.c
  group Applications
    applications/: application.c startup.c
  group gui_examples
    ui_examples/: demo_application.c demo_view.c demo_xml.c demo_view_benchmark.c demo_view_dc.c demo_view_ttf.c demo_view_dc_buffer.c demo_view_animation.c demo_view_buffer_animation.c demo_view_instrument_panel.c demo_view_window.c demo_view_label.c demo_view_button.c demo_view_checkbox.c demo_view_progressbar.c demo_view_scrollbar.c demo_view_radiobox.c demo_view_textbox.c demo_view_listbox.c demo_view_menu.c demo_view_listctrl.c demo_view_combobox.c demo_view_slider.c demo_view_notebook.c demo_view_mywidget.c demo_view_box.c demo_view_edit.c demo_view_bmp.c demo_plot.c mywidget.c demo_view_digtube.c
  group Kernel
    ../../../../../Mygithub/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../../../Mygithub/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../../../Mygithub/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../../../Mygithub/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../../../Mygithub/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../../../Mygithub/components/dfs/filesystems/elmfat/option/: ccfile.c
  group DeviceDrivers
    ../../../../../Mygithub/components/drivers/serial/: serial.c
    ../../../../../Mygithub/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../../../Mygithub/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../../../Mygithub/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group RTGUI
    ../../../../../Mygithub/components/rtgui/apps/: calibration.c
    ../../../../../Mygithub/components/rtgui/common/: animation.c animation_engines.c asc12font.c asc16font.c blit.c color.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c framebuffer_driver.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_xpm.c matrix.c pixel_driver.c region.c rtgui_app.c rtgui_mv_model.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../../../../Mygithub/components/rtgui/server/: driver.c gesture.c mouse.c server.c topwin.c touch.c
    ../../../../../Mygithub/components/rtgui/widgets/: box.c button.c caret.c checkbox.c combobox.c container.c digfont.c digtube.c edit.c filelist_view.c groupbox.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c mv_view.c notebook.c panel.c plot.c plot_curve.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c text_encoding.c textbox.c textview.c title.c widget.c window.c
